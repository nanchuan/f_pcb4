# Keil uVision project fly_app.uvproj, settings and files
target fly_app (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: fly_app +hex
  AfterMake: fromelf.exe --bin -o ..\output\fly_app.bin ..\output\app\fly_app.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c misc: --c99
  c include: .\cmsis;.
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group cmsis
    ./cmsis/: core_cm3.c misc.c stm32f10x_conf.h core_cm3.h misc.h stm32f10x.h startup_stm32f10x_md.s system_stm32f10x.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_usart.c
  group bsp
    ./bsp/: led.c led.h bsp.c bsp.h time.h time.c rf.h rf.c rf_hal.c rf_hal.h i2c.h i2c.c mpu6050.c mpu6050.h i2c_1.c battery.c battery.h motor.c motor.h hmc5883.h hmc5883.c flash.h flash.c uart1.h uart1.c
  group main
    ./: main.c
  group app_communication
    ./app/communication/: interface.h protocol.h communication.h communication.c cmd.h cmd.c nrf24l01p.h nrf24l01p.c engine.h engine.c serial.h serial.c
  group app_math
    ./app/math/: interface.h other.c other.h quaternion.c quaternion.h
  group app_sensor
    ./app/sensor/: interface.h sensor.c sensor.h
  group app_attitude
    ./app/attitude/: interface.h attitude.h attitude.c accfilter.h accfilter.c gyrfilter.h gyrfilter.c magfilter.h magfilter.c mix.h mix.c
  group app_control
    ./app/control/: interface.h control.h control.c pid.h pid.c
  group app_exception
    ./app/exception/: exception.c exception.h interface.h
  group app_status
    ./app/status/: interface.h status.h status.c
  group app_param
    ./app/param/: interface.h param.h param.c
  group readme
    ./readme/: readme.c
